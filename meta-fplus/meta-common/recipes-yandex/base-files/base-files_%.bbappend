FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://profile"
SRC_URI += "file://motd"
SRC_URI += "file://shells"
