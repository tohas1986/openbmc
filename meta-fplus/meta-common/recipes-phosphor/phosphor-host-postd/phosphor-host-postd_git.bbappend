FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Post-only-changed-post-code.patch"
SRC_URI += "file://0002-Add-protection-agains-BIOS-bug.patch"
