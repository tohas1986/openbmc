FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-some-debug-Fix-incorrect-read-of-trigger.patch"

