FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0002-Never-allow-shell-login-for-ipmi-created-users.patch"
