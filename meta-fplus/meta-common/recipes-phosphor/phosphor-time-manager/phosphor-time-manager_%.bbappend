FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-Add-ntpd-restart-and-direct-system-setting-via-date.patch"
