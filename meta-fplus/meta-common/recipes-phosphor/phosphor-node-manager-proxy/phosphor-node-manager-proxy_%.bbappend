FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

#SRC_URI += "file://0001-Changing-IPMB-channel-to-ME.patch"
