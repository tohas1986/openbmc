FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI =+ "file://0001-Allow-addresses-up-to-0x7f.patch"
