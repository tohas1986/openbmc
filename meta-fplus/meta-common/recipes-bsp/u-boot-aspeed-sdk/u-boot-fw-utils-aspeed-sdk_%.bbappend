FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Introduce-yandex_ast2600-board.patch"
SRC_URI += "file://0002-WIP-Yandex.patch"
