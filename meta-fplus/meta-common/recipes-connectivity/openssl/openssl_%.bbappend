FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

# Uncomment to enable AST2600 HACE/ACRY
# SRC_URI += "file://0001-Force-build-of-cryptodev-engine.patch"
