# Class for the only purpose: to store Yandex version
FIXED_Y_VERSION="2.35"
