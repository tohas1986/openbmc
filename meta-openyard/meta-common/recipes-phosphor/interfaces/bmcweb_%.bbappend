EXTRA_OEMESON += "-Dredfish-cpu-log=enabled \
                  -Dredfish-bmc-journal=enabled \
                  -Drest=enabled \
                  -Dredfish-post-to-old-updateservice=enabled"

