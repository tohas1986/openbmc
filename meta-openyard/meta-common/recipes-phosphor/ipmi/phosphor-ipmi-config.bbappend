FILESEXTRAPATHS:append := "${THISDIR}/${PN}:"
SRC_URI:append:openyard = " file://master_write_read_white_list.json"

