FILESEXTRAPATHS:append:dev2600 := "${THISDIR}/${PN}:"