FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://ast2600-openyard.dts"
