DEPENDS:append = " breath-yaml-config"

IPMI_FRU_YAML = "${STAGING_DIR_HOST}${datadir}/breath-yaml-config/ipmi-fru-read.yaml"
IPMI_FRU_PROP_YAML = "${STAGING_DIR_HOST}${datadir}/breath-yaml-config/ipmi-extra-properties.yaml"
