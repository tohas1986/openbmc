
FILES:${PN} += "/usr/share/openpower-pnor-code-mgmt/org.open_power.Software.Host.Updater.conf"
