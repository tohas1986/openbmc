# RDEPENDS:${PN}-inventory:append = " openpower-occ-control id-button"
RDEPENDS:${PN}-inventory:append = " id-button"
RDEPENDS:${PN}-extras:append = " phosphor-image-signing"
