RDEPENDS:${PN}:append = " avsbus-control"
RDEPENDS:${PN}:append = " vrm-control"
