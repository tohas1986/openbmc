FILESEXTRAPATHS:append := "${THISDIR}/files:"

SRC_URI:append = " \
    file://dalegibbs.cfg \
    file://0001-Disable-WDT2.patch \
"

