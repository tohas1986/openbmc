KBRANCH ?= "dev-6.0"
LINUX_VERSION ?= "6.0.10"

#SRCREV="115a0aad1535ce7ab88513002319d6d59334c116"
SRCREV="8b772fa8ec6ef5be7e723b5f9cdda60bd387ed6b"

require linux-aspeed.inc
