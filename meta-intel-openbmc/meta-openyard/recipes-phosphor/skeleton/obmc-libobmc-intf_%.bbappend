FILESEXTRAPATHS:prepend:openyard := "${THISDIR}/${PN}:"
